# Keil uVision project project.uvproj, settings and files
target project (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\BSP\inc;..\SYS;..\APP
  group app
    ../APP/: main.c
  group bsp
    ../BSP/src/: bsp.c drv_i2c.c drv_timer.c drv_lcd_1206a.c drv_key_matrix.c drv_ad_pcf8591.c
  group system
    ../SYS/: sys_delay.c
  group startup
    ./: STARTUP.A51
